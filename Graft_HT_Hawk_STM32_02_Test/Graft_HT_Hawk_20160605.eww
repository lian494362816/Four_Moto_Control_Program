<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Graft_HT_Hawk_STM32_02&#x6B63;&#x5e38;&#x4F7F;&#x7528;&#x7248;\Graft_HT_Hawk_20160605.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\Graft_HT_Hawk_STM32_03\Graft_HT_Hawk_20160605.ewp</path>
  </project>
  <batchBuild/>
</workspace>


