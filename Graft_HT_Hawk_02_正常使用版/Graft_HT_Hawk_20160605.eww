<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\Graft_HT_Hawk_05_ANO&#x5B9A;&#x9AD8;&#x7248;\Graft_HT_Hawk_20160605.ewp</path>
  </project>
  <batchBuild/>
</workspace>


