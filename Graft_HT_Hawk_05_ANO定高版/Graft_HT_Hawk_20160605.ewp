# IAR project Graft_HT_Hawk_20160605.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group Algorithm
    ./: algorithm_filter.c algorithm_filter.h algorithm_math.c algorithm_math.h algorithm_quaternion.c algorithm_quaternion.h algorithm_sqlite.c algorithm_sqlite.h
  group Driver
    ./: clock.c clock.h delay.c delay.h dma0_uart1_tx.c dma0_uart1_tx.h Flash.c Flash.h i2c.c i2c.h key.c key.h led.c led.h moto.c moto.h uart0.c uart0.h uart1.c uart1.h uart2.c uart2.h
  group Function
    ./: multirotor_ahrs.c multirotor_ahrs.h multirotor_app.c multirotor_app.h multirotor_control.c multirotor_control.h Multirotor_radio.c multirotor_radio.h multirotor_rc.c multirotor_rc.h
  group height
    ./: height_ctrl.c height_ctrl.h
  group Modules
    ./: hmc5883.c hmc5883.h mpu6050.c mpu6050.h ms5611.c ms5611.h ultrasonic.c ultrasonic.h
  group Time
    ./: timer.c timer.h
  group User
    ./: board_config.h include.h main.c type.h
